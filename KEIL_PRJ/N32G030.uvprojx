# Keil uVision project N32G030.uvprojx, settings and files
target N32G030 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: N32G030K6 Nationstech
  pack: Nationstech.N32G030_DFP.0.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: N32G031-Boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G030, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\Device;..\Device\CMSIS;..\Device\CMSIS\core;..\Device\CMSIS\device;..\Device\n32g030_std_periph_driver;..\Device\n32g030_std_periph_driver\inc;..\Device\n32g030_std_periph_driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../Device/CMSIS/device/startup/: startup_n32g030.s
  group CMSIS
    ../Device/CMSIS/device/: system_n32g030.c
  group FWLB
    ../Device/n32g030_std_periph_driver/src/: misc.c n32g030_crc.c n32g030_dbg.c n32g030_flash.c n32g030_gpio.c n32g030_hdiv.c n32g030_iwdg.c n32g030_pwr.c n32g030_rcc.c n32g030_sqrt.c n32g030_usart.c n32g030_adc.c n32g030_tim.c
  group USER
    ../USER/: main.c McuHal_N32G030.c bootload.c
